# Keil uVision project BitBand.uvproj, settings and files
target BitBand (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M471R1E6AE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: BitBand
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M471M_R1_S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/ARM/: startup_M471M_R1_S.s
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
  group User
    ../: main.c
