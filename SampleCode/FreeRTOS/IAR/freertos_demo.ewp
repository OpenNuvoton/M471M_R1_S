# IAR project freertos_demo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471x6AE series Nuvoton M471M/R1/S series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include; ..\..\..\Library\StdDriver\inc; ..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..\; ..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: FreeRTOS_Demo.bin
  ILINK.IlinkOutputFile: FreeRTOS_Demo.out
  ILINK.IlinkIcfFile: FreeRTOS_Demo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M471M_R1_S/Source/IAR/: startup_M471M_R1_S.s
    ../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
  group FreeRTOS Files
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: flash.c PollQ.c QueueSet.c
    ../: main.c ParTest.c
