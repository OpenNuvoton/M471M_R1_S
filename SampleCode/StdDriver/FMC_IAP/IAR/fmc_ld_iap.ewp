# IAR project fmc_ld_iap.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471x6AE series Nuvoton M471M/R1/S series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fmc_ld_iap.bin
  ILINK.IlinkOutputFile: FMC_IAP_LD.out
  ILINK.IlinkIcfFile: fmc_ld_iap.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/IAR/: startup_M471M_R1_S.s
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: LDROM_main.c
