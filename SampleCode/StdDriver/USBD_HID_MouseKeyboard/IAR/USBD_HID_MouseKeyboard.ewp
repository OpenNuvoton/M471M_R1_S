# IAR project USBD_HID_MouseKeyboard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471x6AE series Nuvoton M471M/R1/S series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_MouseKeyboard.bin
  ILINK.IlinkOutputFile: USBD_HID_MouseKeyboard.out
  ILINK.IlinkIcfFile: USBD_HID_MouseKeyboard.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/IAR/: startup_M471M_R1_S.s
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usbd.c
  group User
    ../: descriptors.c hid_mousekeyboard.c main.c
