# Keil uVision project SC_ReadATR.uvprojx, settings and files
target SC_ReadATR (6190000::V6.19::ARMCLANG)
  device: M471R1E6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: SC_ReadATR
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M471M_R1_S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/ARM/: startup_M471M_R1_S.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c sc.c
    ../../../../Library/SmartcardLib/: SmartCardLib_Keil.lib
