# Keil uVision project PDMA_ScatterGather_PingPongBuffer.uvprojx, settings and files
target PDMA_ScatterGather_PingPongBuffer (6150000::V6.15::ARMCLANG)
  device: M471R1E6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: PDMA_ScatterGather_PingPongBuffer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M471M_R1_S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/ARM/: startup_M471M_R1_S.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c pdma.c retarget.c uart.c
