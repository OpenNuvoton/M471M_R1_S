# Keil uVision project SYS_PowerDown_MinCurrent.uvproj, settings and files
target SYS_PowerDown_MinCurrent (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M471R1E6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: SYS_PowerDown_MinCurrent
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M471M_R1_S\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M471M_R1_S.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/: system_M471M_R1_S.c
    ../../../../Library/Device/Nuvoton/M471M_R1_S/Source/ARM/: startup_M471M_R1_S.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c gpio.c sys.c uart.c
